# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\User;..\..\User\bsp\inc;..\..\User\bsp;..\..\User\app\inc;..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/app/src/: main.c modbus_slave.c
  group BSP
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_timer.c bsp_uart_fifo.c bsp_user_lib.c bsp_adc.c
    ../../User/bsp/: bsp.c bsp_msg.c stm32f10x_assert.c stm32f10x_it.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp_stm32f4xx\inc;..\..\User\bsp_stm32f4xx;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
